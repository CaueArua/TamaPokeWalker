// TamaPoke is a first-generation-inspired pixel-art virtual pet
// for the Waveshare ESP32-S3-Touch-AMOLED-1.75.
//
// Libraries (Arduino Library Manager or Waveshare repository):
//   - "GFX Library for Arduino" (moononournation), with CO5300 QSPI support
//   - "SensorLib" (Lewis He), for the CST9217 touch controller
//
// Board: ESP32S3 Dev Module | 16 MB Flash | OPI PSRAM | USB CDC On Boot: Enabled
//
// Sprites and the species table are generated by tools/sprites.py (emit).

#include <Arduino.h>
#include <Wire.h>
#include <Preferences.h>
#include <esp_sleep.h>
#include "Arduino_GFX_Library.h"
#include "TouchDrvCSTXXX.hpp"
#include "pin_config.h"
#include "species.h"
#include "dex.h"
#include "pet.h"
#include "sdmon.h"
#include "rtcbat.h"
#include "i18n.h"
#include "audio.h"
#include "battle.h"
#include "time_utils.h"
#include "dayphase.h"
#include "imu.h"
#include "src/ui/party_screen.h"
#include "src/ui/main_screen.h"
#include "src/ui/dex_screen.h"
#include "src/ui/strength_screen.h"
#include "src/ui/battle_screen.h"
#include "src/ui/game_ball_screen.h"
#include "src/ui/game_catch_screen.h"
#include "src/ui/game_memo_screen.h"
#include "src/ui/game_clean_screen.h"
#include "src/ui/game_type_screen.h"
#include "src/ui/game_screen_common.h"
#include "src/ui/pet_card_profile_screen.h"
#include "src/ui/pet_card_page.h"
#include "src/ui/pet_card_personality_screen.h"
#include "src/ui/pet_card_daily_screen.h"
#include "src/ui/pet_card_box_screen.h"
#include "src/ui/pet_card_stats_screen.h"
#include "src/ui/pet_card_medals_screen.h"
#include "src/ui/pet_card_progress_screen.h"
#include "src/ui/pet_card_expedition_screen.h"
#include "src/ui/pet_card_steps_screen.h"
#include "src/ui/clock_screen.h"
#include "src/ui/keyboard_screen.h"
#include "src/ui/help_screen.h"
#include "src/ui/starter_screen.h"

// Firmware version. Increment this for each release and update manifest.json
// for the web installer. It is shown in Settings and printed at startup.
#if defined(TAMAPOKE_LOCAL_TEST) && defined(TAMAPOKE_GEN3_RELEASE)
#error "TAMAPOKE_LOCAL_TEST and TAMAPOKE_GEN3_RELEASE are mutually exclusive"
#endif
#if DEX_COUNT > 251 && !defined(TAMAPOKE_LOCAL_TEST) && !defined(TAMAPOKE_GEN3_RELEASE)
#error "Gen-3 source requires an explicit local-test or release build profile"
#endif
#ifdef TAMAPOKE_LOCAL_TEST
#define FW_VERSION "1.36.2-hoenn-walk-local"
#elif defined(TAMAPOKE_GEN3_RELEASE)
#define FW_VERSION "1.36.2"
#else
#define FW_VERSION "1.35.3-soft-step"
#endif

/**
 * Returns the firmware version selected by the active build profile.
 *
 * @return The version string defined by FW_VERSION.
 */
const char *firmwareVersion() { return FW_VERSION; }

Arduino_DataBus *bus = new Arduino_ESP32QSPI(
  LCD_CS, LCD_SCLK, LCD_SDIO0, LCD_SDIO1, LCD_SDIO2, LCD_SDIO3);
Arduino_CO5300 *panel = new Arduino_CO5300(
  bus, LCD_RESET, 0 /*rotation*/, LCD_WIDTH, LCD_HEIGHT, 6, 0, 0, 0);
// The full framebuffer lives in PSRAM; render complete frames before flushing.
Arduino_Canvas *gfx = new Arduino_Canvas(LCD_WIDTH, LCD_HEIGHT, panel);

TouchDrvCST92xx touch;
Pet pet;

// Animated sprite assets for the current species, when available on the SD card.
SdMon mon;          // Monochrome fallback sprite, also used by minigames.
PmdMon pmd;         // Main-screen PMD sprite with multiple actions.
PmdMon evoPmd;      // Previous form, shown only during the evolution flash.
int16_t monFor = -2;
bool monShinyFor = false;

// Main-pet animation state.
PetBehavior beh;
#define PET_GROUND 304  // Baseline for the pet sprite.

// Shared screen and application state.
bool screenOff = false;       // Toggled by a short press of the power button.
char nameBuf[12] = "";
uint8_t nameLen = 0;
uint8_t cardPage = 0;         // Profile, personality, daily, box, battle, medals, progress, expedition, steps.
bool expeditionTrainChoiceOpen = false;
int clockH = 12, clockM = 0;  // Time currently being edited.
bool powerSave = false;       // Optional power saving; disabled by default.
uint8_t helpPage = 0;
bool uiDirty = true;
bool cardDirty = true;
bool clockDirty = true;
bool helpDirty = true;
bool keyboardDirty = true;
bool gameMenuDirty = true;

int8_t watermarkDrawnSlot = -1;

// Bath-scene bubbles and cleanup state.
uint32_t bathUntil = 0;
bool bathPending = false;
BathBubble bubbles[14];
uint32_t feedMenuUntil = 0;   // Feed selector expiration time.
uint32_t nextAmbientSoundAt = 0;

bool gameMenuOpen = false;


uint32_t wildPromptUntil = 0;
uint32_t nextWildEligible = 0;
uint32_t lastWildCheck = 0;
int16_t wildPromptDex = 0;
uint8_t wildPromptLevel = 1;
bool wildPromptShiny = false;

uint32_t petEventUntil = 0;
uint32_t nextPetEventEligible = 0;
uint32_t lastPetEventCheck = 0;
uint8_t petEventType = PET_EVENT_BERRY;
uint32_t petEventFeedbackUntil = 0;
char petEventMsg[18] = "";
uint32_t morningUntil = 0;
uint32_t eggWiggleUntil = 0;

int sceneHour();
uint8_t currentDayPhase();
uint32_t pmdActTotalMs(const PmdAct &a);
bool watermarkNeedsRedraw();
void flushStampedFrame();
void ensureMon();
void render();

/**
 * Maps one of the nine built-in species to its sprite-table index.
 *
 * @param dex National Dex species identifier.
 * @return The built-in sprite index, or -1 when no built-in sprite exists.
 */
int flashIdxForDex(int16_t dex) {
  static const int8_t IDX[10] = { -1, 3, 4, 5, 0, 1, 2, 6, 7, 8 };
  return (dex >= 1 && dex <= 9) ? IDX[dex] : -1;
}

#define CX 233  // Horizontal center of the round display.
#define CY 233
#define PET_CY 202  // Vertical center of the pet sprite.

static const uint16_t INK_K = 0x18C4;  // Color returned for the sprite palette key 'k'.

/**
 * Loads the persisted power-saving preference from NVS.
 */
void loadPowerSave() {
  Preferences p;
  p.begin("tamapoke", true);
  powerSave = p.getBool("psave", false);
  p.end();
}

/**
 * Updates and persists the power-saving preference.
 *
 * @param on Whether power-saving mode should be enabled.
 */
void setPowerSave(bool on) {
  powerSave = on;
  Preferences p;
  p.begin("tamapoke", false);
  p.putBool("psave", powerSave);
  p.end();
}

// Star positions used by night scenes.
const uint16_t STARS[6][2] = { {120,140},{330,120},{370,210},{95,230},{280,90},{160,95} };

bool wasPressed = false;
// The CST9217 signals pending touch data on INT. Gate I2C reads while it is
// idle because reading the sleeping controller can stall for about one second.
volatile bool gTouchIrq = false;
/**
 * Records a touch-controller interrupt without performing I2C work in the ISR.
 */
void IRAM_ATTR touchIsr() { gTouchIrq = true; }
uint32_t lastRender = 0;
uint32_t lastLoopStart = 0;
uint32_t perfRenderLastMs = 0, perfRenderMaxMs = 0;
uint32_t perfLoopLastMs = 0, perfLoopMaxMs = 0;
uint32_t perfRenderCount = 0, perfRenderSkipCount = 0;
// AMOLED protection and touch-gesture state.
uint32_t lastInteract = 0;
uint8_t dimStage = 0;        // 0 active, 1 dimmed (90 s), 2 nearly off (5 min).
bool swallowGesture = false; // The touch that wakes the display performs no action.
uint32_t ignoreTouchUntil = 0;
uint32_t holdStart = 0;     // Long-press start time on the pet.
uint32_t confirmUntil = 0;  // Expiration time for the release confirmation dialog.
uint8_t choiceKind = 0;     // 0 none, 1 evolution, 2 farewell, 3 evolution target.
uint32_t choiceUntil = 0;   // Expiration time for the choice dialog.
int16_t tX0, tY0, tXl, tYl; // Gesture start and most recent touch coordinates.
uint32_t tStart = 0;
bool holdFired = false;

/**
 * Marks shared UI surfaces and the active screen as needing a redraw.
 */
void markUiDirty() {
  uiDirty = true;
  cardDirty = true;
  clockDirty = true;
  helpDirty = true;
  keyboardDirty = true;
  gameMenuDirty = true;
  if (activeScreen) activeScreen->markDirty();
}

/**
 * Ignores touch input briefly and resets the current gesture.
 *
 * @param ms Duration of the touch lock in milliseconds.
 */
void lockTouchBrief(uint16_t ms = 160) {
  uint32_t until = millis() + ms;
  if (until > ignoreTouchUntil) ignoreTouchUntil = until;
  wasPressed = false;
  swallowGesture = true;
}

/**
 * Returns a short identifier for the currently displayed screen.
 *
 * @return The active screen name used by diagnostics.
 */
const char *screenName() {
  if (!activeScreen) {
    if (gameMenuOpen) return "game-menu";
    return screenOff ? "screen-off" : "main";
  }
  if (activeScreen == &dexScreen) return dexScreen.isDetail() ? "gallery-detail" : "gallery-grid";
  if (activeScreen->isMinigame()) return "game";
  if (activeScreen == &strengthTrainingScreen) return "sack";
  if (activeScreen == &battleScreen) return battleScreen.isResolved() ? "battle-result" : "battle";
  if (activeScreen == &keyboardScreen) return "keyboard";
  if (activeScreen == &helpScreen) return "help";
  if (activeScreen == &clockSettingsScreen) return "settings";
  if (activeScreen->isPetCardPage()) return "card";
  if (activeScreen == &partyScreen || activeScreen == &partyReplaceScreen) return "party";
  if (activeScreen == &starterScreen) return "starter";
  if (gameMenuOpen) return "game-menu";
  return "screen";
}

/**
 * Reports whether the current view can skip rendering because it is clean.
 *
 * @return True when the active screen or main-screen overlay needs no redraw.
 */
bool staticScreenClean() {
  if (watermarkNeedsRedraw()) return false;
  if (activeScreen) return activeScreen->isStaticClean();
  if (gameMenuOpen) return !gameMenuDirty;
  return false;
}

/**
 * Initializes serial, display, touch, pet storage, peripherals, and services.
 */
void setup() {
  Serial.setRxBufferSize(8192);  // SD transfers arrive in 2 KB blocks.
  Serial.begin(115200);
  // Critical: without this, Serial.print can block gameplay when no host
  // monitor is connected and the USB CDC TX buffer fills. A zero timeout
  // drops those optional log messages instead of blocking the firmware.
  Serial.setTxTimeoutMs(0);
  Serial.printf("TamaPoke fw v%s\n", FW_VERSION);
  loadLang();  // Load the saved language (Spanish by default).
  Wire.begin(IIC_SDA, IIC_SCL);
  // The CST9217 touch controller, AXP2101 PMU, and PCF85063 RTC share I2C.
  // This timeout protects PMU/RTC operations. SensorLib does not honor it for
  // touch reads; those are protected by gating reads on INT in handleTouch().
  Wire.setTimeOut(50);

  // Critical: enable the panel power rail (BLDO1 = OLED VDD 3.3 V) before
  // initializing the display. A PMU reset can leave this rail off and the
  // display black even while the rest of the board is running.
  pmuEnablePanel();

  // Use 80 MHz QSPI instead of the 40 MHz default; framebuffer flush is the
  // frame-rate bottleneck (~56 ms at 40 MHz). Reduce this if the panel corrupts.
  if (!gfx->begin(80000000)) Serial.println("gfx->begin() fallo");
  panel->setBrightness(180);

  touch.setPins(TP_RESET, TP_INT);
  bool touchOk = false;
  for (int i = 0; i < 3 && !touchOk; i++) {  // Initialization can fail intermittently.
    touchOk = touch.begin(Wire, 0x5A, IIC_SDA, IIC_SCL);
    if (!touchOk) delay(150);
  }
  if (!touchOk) Serial.println("CST9217 no detectado");
  // begin() reads the controller identity but leaves it in command mode;
  // a hardware reset is required before it reports touches again.
  touch.reset();
  touch.setMaxCoordinates(LCD_WIDTH, LCD_HEIGHT);
  touch.setMirrorXY(true, true);  // The panel is mounted rotated by 180 degrees.
  // INT is active-low and signals pending data; it gates touch I2C reads.
  pinMode(TP_INT, INPUT_PULLUP);
  attachInterrupt(digitalPinToInterrupt(TP_INT), touchIsr, FALLING);

  pet.begin();
  if (pet.awaitingStarter()) setScreen(&starterScreen);
  Serial.printf("SAVE %s spec=%d lv=%u wins=%u losses=%u streak=%u\n",
                pet.saveLoadedFromNvs ? "loaded" : "created",
                pet.speciesId, pet.level(), pet.battleWins, pet.battleLosses, pet.battleStreak);
  sdBegin();
  thumbs.load();

  // Synchronize the pet with the real-time clock, including powered-off time.
  rtcBegin();
  batBegin();
  pwrSetup();
  uint32_t e = rtcEpoch();
  if (e == 0) {
    rtcSetEpoch(1767225600UL);  // Seed a blank RTC; only elapsed-time differences matter.
    e = rtcEpoch();
    Serial.println("RTC sin hora: sembrado, sin progresion offline esta vez");
  }
  pet.syncClock(e);
  loadPowerSave();
  imuBegin();

  ensureMon();
  render();
  lastRender = millis();

  audioBegin();  // Initialize ES8311, I2S, and the amplifier; play the startup jingle.

  lastInteract = millis();
}

/**
 * Reloads the current species sprite when its species, form, or SD state changes.
 */
void ensureMon() {
  if (pet.speciesId == monFor && monShinyFor == pet.shiny && !sdDirty) return;
  sdDirty = false;
  monFor = pet.speciesId;
  monShinyFor = pet.shiny;
  mon.unload();
  pmd.unload();
  beh.x = beh.targetX = 233;
  beh.mode = 0;
  beh.until = 0;
  if (pet.speciesId >= 1 && pet.speciesId <= DEX_COUNT) {
    pmd.load(pet.speciesId, pet.shiny);          // Prefer the animated PMD sprite.
    if (!pmd.loaded) mon.load(pet.speciesId, pet.shiny);  // Fall back to the monochrome sprite.
  }
}

/**
 * Checks whether ambient sounds may play on the main screen.
 *
 * @return True when gameplay and display state allow ambient audio.
 */
bool mainScreenReadyForAmbientSound() {
  if (audioMode() != SOUND_FULL || screenOff || dimStage > 0) return false;
  if (pet.awaitingStarter() || pet.isEgg() || pet.sleeping || pet.ceremony) return false;
  if (activeScreen || gameMenuOpen) return false;
  if (feedMenuUntil || confirmUntil || choiceKind || bathUntil || wildPromptUntil || petEventUntil) return false;
  if (pet.evolving() || pet.wantEvolveButton() || pet.canRunawayNow() || pet.wantFarewellButton()) return false;
  return true;
}

/**
 * Plays an occasional ambient sound while the pet is idle on the main screen.
 *
 * @param now Current uptime in milliseconds.
 */
void maybePlayAmbientSound(uint32_t now) {
  if (!mainScreenReadyForAmbientSound()) {
    nextAmbientSoundAt = now + 9000;
    return;
  }
  if (nextAmbientSoundAt == 0) nextAmbientSoundAt = now + 8000 + random(8000);
  if (deadlineActive(now, nextAmbientSoundAt)) return;
  uint8_t r = (uint8_t)random(3);
  sfxPlay(r == 0 ? SFX_HEART : (r == 1 ? SFX_EVENT_SPARKLE : SFX_MENU));
  nextAmbientSoundAt = now + 8000 + random(8000);
}

/**
 * Selects the render cadence for the active screen and power state.
 *
 * @return The minimum interval between rendered frames, in milliseconds.
 */
uint16_t renderIntervalMs() {
  if (screenOff) return 5000;
  if (activeScreen == &battleScreen) return battleScreen.isResolved() ? 320 : 190;
  if (activeScreen && (activeScreen->isMinigame() || activeScreen == &strengthTrainingScreen)) return 115;
  if (activeScreen == &dexScreen ||
      (activeScreen && activeScreen->isPetCardPage()) ||
      activeScreen == &keyboardScreen || activeScreen == &clockSettingsScreen ||
      activeScreen == &helpScreen || gameMenuOpen) return powerSave ? 650 : 320;
  if (!powerSave) return 100;
  if (dimStage >= 2) return 650;
  if (dimStage >= 1) return 350;
  return 180;
}

/**
 * Determines whether the device can enter light sleep without interrupting UI.
 *
 * @param now Current uptime in milliseconds.
 * @return True when all hardware, input, and screen conditions permit sleep.
 */
bool lightSleepAllowed(uint32_t now) {
  if (!powerSave || usbPresent() || audioBusy() || Serial.available()) return false;
  if (!screenOff && dimStage == 0) return false;
  if (!screenOff && now - lastInteract < 1500UL) return false;
  if (wasPressed || gTouchIrq || deadlineActive(now, ignoreTouchUntil)) return false;
  if (activeScreen || bathUntil) return false;
  if (pet.awaitingStarter() || feedMenuUntil || confirmUntil || choiceKind || wildPromptUntil || petEventUntil) return false;
  if (pet.evolving() || pet.ceremony || pet.eating() || pet.showHeart()) return false;
  if (gameMenuOpen) return false;
  return true;
}

/**
 * Computes a bounded light-sleep duration that preserves rendering and IMU polling.
 *
 * @param now Current uptime in milliseconds.
 * @return The sleep duration in milliseconds, or zero when sleep is not allowed.
 */
uint16_t lightSleepMs(uint32_t now) {
  if (!lightSleepAllowed(now)) return 0;
  uint16_t maxMs = screenOff ? 750 : (dimStage >= 2 ? 300 : 180);
  // Software step detection still needs regular raw samples while the display
  // is dimmed. Short light-sleep intervals provide them without continuous rendering.
  if (imuOk() && maxMs > 70) maxMs = 70;
  uint16_t ri = renderIntervalMs();
  uint32_t sinceRender = now - lastRender;
  if (sinceRender < ri) {
    uint32_t untilRender = ri - sinceRender;
    if (untilRender < maxMs) maxMs = untilRender;
  }
  if (maxMs < 40) return 0;
  return maxMs;
}

/**
 * Enters light sleep for the duration selected by lightSleepMs() and records touch wakeups.
 *
 * @param now Current uptime in milliseconds.
 */
void maybeLightSleep(uint32_t now) {
  uint16_t ms = lightSleepMs(now);
  if (!ms) return;

  esp_sleep_disable_wakeup_source(ESP_SLEEP_WAKEUP_ALL);
  esp_sleep_enable_timer_wakeup((uint64_t)ms * 1000ULL);
  esp_sleep_enable_ext0_wakeup((gpio_num_t)TP_INT, 0);
  esp_light_sleep_start();

  if (digitalRead(TP_INT) == LOW || esp_sleep_get_wakeup_cause() == ESP_SLEEP_WAKEUP_EXT0) {
    gTouchIrq = true;
  }
}

/**
 * Runs one firmware iteration: updates the pet, polls hardware, renders, and sleeps.
 */
void loop() {
  uint32_t now = millis();
  uint32_t loopStart = now;
  bool petChanged = pet.update(now);
  if (petChanged && activeScreen == petCardScreenForPage(cardPage) && cardPage != 7)
    activeScreen->markDirty();

  // Play a sound when the pet becomes eligible to evolve, including after waking.
  // wantEvolveButton() already excludes pets that are still asleep.
  static bool wasEvoReady = false;
  bool evoReady = pet.wantEvolveButton();
  if (evoReady && !wasEvoReady) sfxPlay(SFX_MEDAL);
  wasEvoReady = evoReady;
  // Play a warning when neglect makes the pet eligible to run away.
  static bool wasRunReady = false;
  bool runReady = pet.canRunawayNow();
  if (runReady && !wasRunReady) sfxPlay(SFX_DENY);
  wasRunReady = runReady;

  handleTouch();
  handleSerial();
  ensureMon();
  setPowerCacheInterval(powerSave ? 10000UL : 2000UL);
  pet.ensureDailyGoals();
  mainScreen.update(now);
  maybePlayAmbientSound(now);

  uint16_t imuMs = screenOff ? 70 : (dimStage ? 60 : 40);
  imuPoll(now, imuMs);
  uint32_t stepsBefore = pet.stepsToday;
  uint32_t stepDayBefore = pet.stepDay;
  uint16_t walked = imuTakeSteps();
  // The detector already filters isolated impacts and requires a walking rhythm.
  // Count steps immediately after USB is unplugged; cached VBUS state could
  // otherwise discard real steps for up to ten seconds.
  if (walked) {
    pet.applyWalk(walked, rtcEpoch());
  }
  mainScreen.updateWalkCards(walked, stepsBefore, stepDayBefore);
  if (imuShakeEdge() && !screenOff) {
    if (pet.isEgg()) {
      eggWiggleUntil = now + 450;
      sfxPlay(SFX_TAP);
    } else if (mainScreen.readyForShake()) {
      lastInteract = now;
      if (pmd.has(PMD_POSE)) {
        beh.mode = 2;
        beh.act = PMD_POSE;
        beh.t0 = now;
        beh.until = now + pmdActTotalMs(pmd.acts[PMD_POSE]);
      }
      if (pet.applyShake()) {
        if (audioMode() == SOUND_FULL) speciesChirpPlay(pet.speciesId, true);
        else sfxPlay(SFX_HEART);
        snprintf(petEventMsg, sizeof(petEventMsg), "%s", T(S_HAPPY_FB));
        petEventFeedbackUntil = now + 1600;
      } else {
        sfxPlay(SFX_TAP);
      }
    }
  }

  // A short PWR press toggles the display on or off.
  static uint32_t lastPwr = 0;
  if (now - lastPwr > 250) {
    lastPwr = now;
    if (pwrShortPressed()) {
      bool wasOff = screenOff;
      screenOff = !screenOff;
      if (!screenOff) {
        lastInteract = now;
        if (wasOff) {
          ignoreTouchUntil = now + 900;
          swallowGesture = true;
          wasPressed = false;
        }
      }
    }
  }

  updateBrightness(now);

  // Flush periodic saves only while the display is dimmed/off or the pet sleeps.
  // NVS writes can stall both cores for about one second; at this point no
  // animation or active touch response is interrupted. Normal actions also save
  // immediately, so active gameplay remains persisted.
  if (pet.savePending() && (screenOff || dimStage >= 1 || pet.sleeping)) {
    pet.flushSave();
  }

  // Refresh the real clock periodically; the value is persisted with game saves.
  static uint32_t lastClock = 0;
  uint32_t clockPollMs = powerSave ? 60000UL : 30000UL;
  if (now - lastClock > clockPollMs) {
    lastClock = now;
    uint32_t e = rtcEpoch();
    if (e) pet.lastSeenEpoch = e;
  }

  mainScreen.updateExpedition(now);

  // Emit a five-minute health heartbeat for soak testing; ignore it without a monitor.
  static uint32_t lastHealth = 0;
  uint32_t healthMs = powerSave ? 600000UL : 300000UL;
  if (now - lastHealth > healthMs) {
    lastHealth = now;
    Serial.printf("HEALTH up=%lus heap=%u min=%u rMax=%lums lMax=%lums screen=%s\n",
                  (unsigned long)(now / 1000), ESP.getFreeHeap(), ESP.getMinFreeHeap(),
                  (unsigned long)perfRenderMaxMs, (unsigned long)perfLoopMaxMs, screenName());
    perfRenderMaxMs = 0;
    perfLoopMaxMs = 0;
  }

  // Use conservative game and battle cadences so rendering does not overlap
  // the previous DMA transfer. Clean static screens skip rendering.
  if (now - lastRender >= renderIntervalMs()) {
    lastRender = now;
    uint32_t rt0 = millis();
    render();
    perfRenderLastMs = millis() - rt0;
    if (perfRenderLastMs > perfRenderMaxMs) perfRenderMaxMs = perfRenderLastMs;
    perfRenderCount++;
  }

  maybeLightSleep(millis());
  perfLoopLastMs = millis() - loopStart;
  if (perfLoopLastMs > perfLoopMaxMs) perfLoopMaxMs = perfLoopLastMs;
  lastLoopStart = loopStart;
}

/**
 * Updates AMOLED brightness according to pet sleep, user inactivity, and power state.
 *
 * @param now Current uptime in milliseconds.
 */
void updateBrightness(uint32_t now) {
  // Visible pet animations keep the display awake.
  if (pet.evolving() || pet.ceremony || pet.eating() || pet.showHeart()) {
    lastInteract = now;
  }
  uint32_t idle = now - lastInteract;
  dimStage = (idle > 300000) ? 2 : (idle > 90000) ? 1 : 0;
  uint8_t target = pet.sleeping ? 25 : (usbPresent() ? 180 : 145);
  if (dimStage == 1) target = pet.sleeping ? 10 : 60;
  else if (dimStage == 2) target = 8;
  if (screenOff) target = 0;
  static uint8_t current = 255;
  if (target != current) {
    current = target;
    panel->setBrightness(target);
  }
}

// Serial console for SD provisioning, save backups, diagnostics, and local testing.

/**
 * Reads and dispatches one serial command or SD transfer request.
 */
void handleSerial() {
  if (!Serial.available()) return;
  String line = Serial.readStringUntil('\n');
  line.trim();
  if (line.length() == 0) return;
  if (sdSerialCommand(line)) return;

  // Browser save-backup protocol:
  // SAVEGET -> "SAVE <bytes>" + hex data + DONE.
  // SAVEPUT <bytes> -> OK + raw data -> DONE, then reboot. Pet validates the
  // checksum and rejects altered or incomplete snapshots before updating NVS.
  if (line == "SAVEGET") {
    uint8_t backup[Pet::BACKUP_MAX_BYTES];
    size_t size = pet.exportBackup(backup, sizeof(backup));
    if (!size) { Serial.println("ERR"); return; }
    // Normal game logs must not block when no terminal is connected, so setup
    // uses a zero TX timeout. A connected browser explicitly requests backups;
    // wait briefly for the complete hex response instead of dropping its data.
    Serial.setTxTimeoutMs(1500);
    Serial.printf("SAVE %u\n", (unsigned)size);
    Serial.print("SAVEHEX ");
    static const char HEX_CHARS[] = "0123456789ABCDEF";
    for (size_t i = 0; i < size; ++i) { Serial.print(HEX_CHARS[backup[i] >> 4]); Serial.print(HEX_CHARS[backup[i] & 15]); }
    Serial.println();
    Serial.println("DONE");
    Serial.flush();
    Serial.setTxTimeoutMs(0);
    return;
  }
  if (line.startsWith("SAVEPUT ")) {
    uint32_t size = (uint32_t)line.substring(8).toInt();
    if (size == 0 || size > Pet::BACKUP_MAX_BYTES) { Serial.println("ERR"); return; }
    uint8_t backup[Pet::BACKUP_MAX_BYTES];
    Serial.println("OK");
    Serial.setTimeout(6000);
    size_t got = Serial.readBytes(backup, size);
    Serial.setTimeout(1000);
    if (got != size || !pet.importBackup(backup, size)) { Serial.println("ERR"); return; }
    Serial.println("DONE");
    delay(150);
    ESP.restart();
    return;
  }

  if (line == "PERF") {
    Serial.printf("screen=%s render=%lums max=%lums count=%lu skip=%lu loop=%lums loopMax=%lums interval=%u dirty ui=%d card=%d clock=%d help=%d kb=%d menu=%d battle=%d gallery=%d\n",
                  screenName(),
                  (unsigned long)perfRenderLastMs, (unsigned long)perfRenderMaxMs,
                  (unsigned long)perfRenderCount, (unsigned long)perfRenderSkipCount,
                  (unsigned long)perfLoopLastMs, (unsigned long)perfLoopMaxMs,
                  renderIntervalMs(), uiDirty, cardDirty, clockDirty, helpDirty,
                  keyboardDirty, gameMenuDirty, battleScreen.isDirty(), dexScreen.isDirty());
    perfRenderMaxMs = 0;
    perfLoopMaxMs = 0;
    Serial.println("DONE");
  } else if (line == "HATCH") {
    pet.eggTap(); pet.eggTap(); pet.eggTap();
    Serial.println("DONE");
  } else if (line.startsWith("SPEC ")) {
    int n = line.substring(5).toInt();
    if (n >= 1 && n <= DEX_COUNT) {
      pet.prevSpeciesId = pet.speciesId;
      pet.speciesId = n;
      Serial.printf("especie #%d %s\n", n, DEX_TBL[n].name);
    }
    Serial.println("DONE");
  } else if (line.startsWith("LVL ")) {
    pet.ageMinutes = (uint32_t)line.substring(4).toInt() * MINUTES_PER_LEVEL;
    Serial.println("DONE");
  } else if (line.startsWith("TIME ")) {
    uint32_t e = (uint32_t)line.substring(5).toInt();
    rtcSetEpoch(e);
    pet.setClock(e);
    Serial.printf("rtc=%u\n", rtcEpoch());
    Serial.println("DONE");
  } else if (line.startsWith("RTCSET ")) {  // Set only the RTC to simulate powered-off time.
    rtcSetEpoch((uint32_t)line.substring(7).toInt());
    Serial.printf("rtc=%u\n", rtcEpoch());
    Serial.println("DONE");
  } else if (line == "TIME") {
    Serial.printf("rtc=%u\n", rtcEpoch());
    Serial.println("DONE");
  } else if (line == "GAL") {
    if (activeScreen == &dexScreen) {
      setScreen(nullptr);
    } else {
      dexScreen.openGrid();
      setScreen(&dexScreen);
    }
    Serial.println("DONE");
  } else if (line == "EGGS") {
    // Simulate 20 egg-species rolls without changing game state.
    for (int i = 0; i < 20; i++) {
      int16_t d = pet.pickEggSpecies();
      Serial.printf("%d:%s(r%u) ", d, DEX_TBL[d].name, DEX_TBL[d].rarity);
    }
    Serial.println();
    Serial.println("DONE");
  } else if (line == "SHINY") {  // Toggle the current pet's shiny state for testing.
    pet.shiny = !pet.shiny;
    Serial.printf("shiny=%d\n", pet.shiny);
    Serial.println("DONE");
  } else if (line.startsWith("NICK ")) {
    pet.rename(line.substring(5).c_str());
    Serial.printf("nick=%s\n", pet.nick);
    Serial.println("DONE");
  } else if (line == "CAREDAY") {  // Simulate a new day of care for testing.
    pet.setClock(pet.lastSeenEpoch + 86400);
    pet.caress();
    Serial.printf("streak=%u bond=%u medals=0x%X\n", pet.streak, pet.bond, pet.medals);
    Serial.println("DONE");
  } else if (line == "BYE") {
    pet.startFarewell();
    Serial.println("DONE");
  } else if (line == "RUN") {
    pet.startRunaway();
    Serial.println("DONE");
  } else if (line == "BEEP") {
    sfxPlay(SFX_HATCH);  // Test audio playback.
    Serial.println("DONE");
  } else if (line == "ABANDON") {
    pet.dbgRunawayReady();  // Force runaway readiness to test its prompt.
    Serial.println("DONE");
  } else if (line == "WIPE") {
    pet.factoryReset();     // Erase NVS and reboot into a new starter selection.
    Serial.println("DONE");
    delay(100);
    ESP.restart();
  } else if (line == "REG") {
    Serial.printf("pokedex %u/%u:", pet.registeredCount(), DEX_COUNT);
    for (int i = 1; i <= DEX_COUNT; i++)
      if (pet.isRegistered(i)) Serial.printf(" %d", i);
    Serial.println();
    Serial.println("DONE");
#ifdef TAMAPOKE_LOCAL_TEST
  } else if (line.startsWith("TESTMON ")) {
    int split = line.indexOf(' ', 8);
    int n = line.substring(8, split < 0 ? line.length() : split).toInt();
    int shinyFlag = split < 0 ? 0 : line.substring(split + 1).toInt();
    if (n >= 1 && n <= DEX_COUNT) {
      pet.prevSpeciesId = pet.speciesId;
      pet.speciesId = n;
      pet.shiny = shinyFlag != 0;
      pet.sleeping = false;
      pet.ceremony = CER_NONE;
      markUiDirty();
      Serial.printf("testmon #%d %s shiny=%d\n", n, DEX_TBL[n].name, pet.shiny);
    }
    Serial.println("DONE");
  } else if (line.startsWith("TESTEVO ")) {
    int split = line.indexOf(' ', 8);
    int source = line.substring(8, split < 0 ? line.length() : split).toInt();
    int target = split < 0 ? 0 : line.substring(split + 1).toInt();
    if (source >= 1 && source <= DEX_COUNT) {
      pet.speciesId = source;
      pet.prevSpeciesId = -1;
      pet.sleeping = false;
      pet.ceremony = CER_NONE;
      pet.resetEvolutionDeferral();
      pet.careMistakes = 0;
      uint8_t requiredLevel = pet.evolutionRequiredLevelFor(target);
      pet.ageMinutes = (uint32_t)(requiredLevel > 0 ? requiredLevel - 1 : 0) * MINUTES_PER_LEVEL;
      pet.fullness = pet.joy = pet.energy = pet.hygiene = 80;
      pet.bond = 60;
      pet.trAtk = pet.trDef = pet.trSpe = 0;
      uint32_t testEpoch = 1767225600UL + 12UL * 3600UL;
      if (target == 197) testEpoch += 9UL * 3600UL;
      pet.setClock(testEpoch);
      if (source == 236) {
        if (target == 106) pet.trAtk = 80;
        else if (target == 107) pet.trDef = 80;
        else pet.trAtk = pet.trDef = 40;
      }
      markUiDirty();
      Serial.printf("testevo #%d -> #%d level=%u bond=%u\n", source, target,
                    pet.level(), pet.bond);
    }
    Serial.println("DONE");
  } else if (line == "CAUGHT") {
    Serial.printf("caught %u/%u:", pet.caughtCount(), DEX_COUNT);
    for (int i = 1; i <= DEX_COUNT; i++)
      if (pet.isCaught(i)) Serial.printf(" %d", i);
    Serial.println();
    Serial.println("DONE");
  } else if (line.startsWith("CAUGHT ")) {
    int n = line.substring(7).toInt();
    if (n < 1 || n > DEX_COUNT) n = pet.speciesId;
    if (n >= 1 && n <= DEX_COUNT) {
      pet.registerCaught((int16_t)n);
      Serial.printf("caught #%d %s\n", n, DEX_TBL[n].name);
    }
    Serial.println("DONE");
  } else if (line.startsWith("BATTLE ")) {
    int split = line.indexOf(' ', 7);
    int n = line.substring(7, split < 0 ? line.length() : split).toInt();
    int8_t shinyOverride = -1;
    if (split >= 0) shinyOverride = line.substring(split + 1).toInt() ? 1 : 0;
    battleScreen.start((int16_t)n, pet.level(), shinyOverride);
    int16_t opponent = battleScreen.opponentDex();
    Serial.printf("battle #%d %s shiny=%d caught=%d\n", opponent,
                  (opponent >= 1 && opponent <= DEX_COUNT) ? DEX_TBL[opponent].name : "?",
                  battleScreen.opponentShiny(), pet.isCaught(opponent));
    Serial.println("DONE");
  } else if (line == "BATTLE") {
    battleScreen.start();
    int16_t opponent = battleScreen.opponentDex();
    Serial.printf("battle #%d %s caught=%d\n", opponent,
                  (opponent >= 1 && opponent <= DEX_COUNT) ? DEX_TBL[opponent].name : "?",
                  pet.isCaught(opponent));
    Serial.println("DONE");
#endif
  } else if (line == "SAVEINFO") {
    Serial.printf("fw=%s save=%s createdBoot=%d spec=%d level=%u egg=%d starter=%d age=%lu\n",
                  FW_VERSION, pet.saveLoadedFromNvs ? "loaded" : "created",
                  pet.saveCreatedThisBoot, pet.speciesId, pet.level(), pet.isEgg(),
                  pet.awaitingStarter(), (unsigned long)pet.ageMinutes);
    Serial.printf("battle wins=%u losses=%u streak=%u best=%u nick=%s\n",
                  pet.battleWins, pet.battleLosses, pet.battleStreak,
                  pet.bestBattleStreak, pet.nick);
    Serial.printf("records ball=%u catch=%u memo=%u sack=%u\n",
                  pet.gameHi, pet.catchHi, pet.memoHi, pet.strHi);
    Serial.println("DONE");
  } else if (line == "HEALTH") {
    Serial.printf("up=%lus heap=%u min=%u sd=%d mon=%d\n",
                  (unsigned long)(millis() / 1000), ESP.getFreeHeap(),
                  ESP.getMinFreeHeap(), sdReady, pmd.loaded || mon.loaded);
    Serial.println("DONE");
  } else if (line == "STATS") {
    Serial.printf("spec=%d nv=%u com=%u fel=%u ene=%u lim=%u desc=%u sd=%d mon=%d bat=%d usb=%d rtc=%u\n",
                  pet.speciesId, pet.level(), pet.fullness, pet.joy, pet.energy,
                  pet.hygiene, pet.careMistakes, sdReady, mon.loaded,
                  batPercent(), usbPresent(), rtcEpoch());
    Serial.printf("peso=%u fue=%u def=%u vel=%u genes=%u/%u/%u tr=%u/%u/%u baya=%d\n",
                  pet.weight, pet.atkStat(), pet.defStat(), pet.speStat(),
                  pet.geneAtk, pet.geneDef, pet.geneSpe,
                  pet.trAtk, pet.trDef, pet.trSpe, pet.berryKnown);
    Serial.printf("shiny=%d streak=%u/%u bond=%u medals=0x%X(%u) nick=%s\n",
                  pet.shiny, pet.streak, pet.bestStreak, pet.bond, pet.medals,
                  pet.totalMedals, pet.nick);
    Serial.printf("steps=%lu/%lu trail=%u shinyLuck=%u/4096 catchBonus=%u\n",
                  (unsigned long)pet.stepsToday, (unsigned long)pet.stepsTotal,
                  pet.stepTrailRank(), pet.stepShinyChancePer4096(), pet.stepCatchBonus());
    Serial.println("DONE");
  } else if (line == "IMU") {
    Serial.printf("imu=%d addr=0x%02X mag=%.2f gyro=%.0f rawPed=%lu softPed=%lu phase=%u hour=%d\n",
                  imuOk(), imuAddr(), imuLastMagG(), imuLastGyroDps(),
                  (unsigned long)imuPedometer(), (unsigned long)imuSoftwarePedometer(),
                  currentDayPhase(), sceneHour());
    Serial.println("DONE");
  } else if (line == "SHAKE") {
    bool okShake = pet.applyShake();
    Serial.printf("shake=%d joy=%u\n", okShake, pet.joy);
    Serial.println("DONE");
  } else if (line.startsWith("WALK ")) {
    uint16_t n = (uint16_t)line.substring(5).toInt();
    uint8_t gained = pet.applyWalk(n, rtcEpoch());
    Serial.printf("walk=%u today=%lu total=%lu joy=%u bond=%u\n", gained,
                  (unsigned long)pet.stepsToday, (unsigned long)pet.stepsTotal,
                  pet.joy, pet.bond);
    Serial.println("DONE");
  } else if (line == "STEPS") {
    Serial.printf("steps today=%lu total=%lu rank=%u shiny=%u/4096 catch+%u usb=%d imu=%d raw=%lu soft=%lu\n",
                  (unsigned long)pet.stepsToday, (unsigned long)pet.stepsTotal,
                  pet.stepTrailRank(), pet.stepShinyChancePer4096(), pet.stepCatchBonus(),
                  usbPresent(), imuOk(), (unsigned long)imuPedometer(),
                  (unsigned long)imuSoftwarePedometer());
    Serial.println("DONE");
  }
}

// Touch input polling and gesture recognition.

/**
 * Tests whether a touch coordinate lies inside the pet's interaction area.
 *
 * @param x Horizontal display coordinate.
 * @param y Vertical display coordinate.
 * @return True when the point is inside the pet hitbox.
 */
bool inPetZone(int16_t x, int16_t y) {
  return x > 110 && x < 356 && y > 95 && y < 310;
}

/**
 * Polls the touch controller and resolves taps, swipes, and long presses.
 *
 * Touch reads are gated by the interrupt pin to avoid blocking on an idle
 * CST9217 controller.
 */
void handleTouch() {
  static uint32_t lastPoll = 0;
  uint32_t now = millis();
  if (deadlineActive(now, ignoreTouchUntil)) {
    gTouchIrq = false;
    wasPressed = false;
    return;
  }
  if (now - lastPoll < (powerSave && screenOff ? 80UL : 20UL)) return;  // 50 Hz while active; slower with the display off.
  lastPoll = millis();
  // Read I2C only when INT signals data or a pressed touch must be tracked
  // until release. Reading the idle CST9217 can stall the loop for about one
  // second, and SensorLib does not honor Wire's timeout.
  if (!gTouchIrq && !wasPressed) return;
  gTouchIrq = false;
  int16_t x, y;
  bool pressed = touch.getPoint(&x, &y, 1) > 0;

  // When PWR has turned the display off, ignore accidental brushes.
  // A short PWR press still wakes it immediately; touch requires a long press.
  if (screenOff) {
    if (pressed && !wasPressed) {
      tX0 = tXl = x;
      tY0 = tYl = y;
      tStart = now;
      holdFired = false;
      wasPressed = true;
    } else if (pressed) {
      tXl = x;
      tYl = y;    
      uint32_t heldMs = millis() - tStart;
      if (!holdFired && !swallowGesture && activeScreen &&
          abs(tXl - tX0) < 30 && abs(tYl - tY0) < 30 &&
          heldMs >= activeScreen->longPressDelayMs()) {
        activeScreen->handleLongPress(tX0, tY0, heldMs);
        holdFired = true;
        return;
      }
      // A stationary long press on the pet opens the release confirmation.
      if (!holdFired && !swallowGesture && !activeScreen && heldMs > 3000 &&
          abs(tXl - tX0) < 30 && abs(tYl - tY0) < 30 && inPetZone(tX0, tY0) &&
          !pet.isEgg() && !confirmUntil && !pet.ceremony) {
        mainScreen.beginReleaseConfirmation();
        holdFired = true;
      }
    } else {
      wasPressed = false;
      holdFired = false;
    }
    return;
  }

  // Strength training counts each press immediately.
  if (activeScreen == &strengthTrainingScreen) {
    if (pressed && !wasPressed) {
      activeScreen->handlePress(y);
    }
    wasPressed = pressed;
    return;
  }

  if (pressed && !wasPressed) {  // Start a new gesture.
    tX0 = tXl = x;
    tY0 = tYl = y;
    tStart = millis();
    holdFired = false;
    swallowGesture = (dimStage > 0) || screenOff;  // A dimmed-screen touch only wakes the display.
    screenOff = false;
    lastInteract = millis();
    if (!swallowGesture && activeScreen && activeScreen->handlesTapOnPress()) {
      activeScreen->handleTap(x, y);  // Handle screens configured for press-time taps.
      swallowGesture = true;  // Prevent a second tap when the finger is released.
    }
  } else if (pressed) {  // Continue tracking the held gesture.
    tXl = x;
    tYl = y;
    // A stationary long press on the pet opens the release confirmation.
    if (!holdFired && !swallowGesture && !activeScreen && millis() - tStart > 3000 &&
        abs(tXl - tX0) < 30 && abs(tYl - tY0) < 30 && inPetZone(tX0, tY0) &&
        !pet.isEgg() && !confirmUntil && !pet.ceremony) {
      mainScreen.beginReleaseConfirmation();
      holdFired = true;
    }
  } else if (wasPressed) {  // Resolve the gesture when the finger is released.
    lastInteract = millis();
    int dx = tXl - tX0, dy = tYl - tY0;
    uint32_t dt = millis() - tStart;
    if (!holdFired && !swallowGesture) {
      if (abs(dx) > 80 && abs(dy) < 70 && dt < 800) onSwipe(dx > 0 ? 1 : -1);
      else if (abs(dy) > 80 && abs(dx) < 70 && dt < 800) onSwipeV(dy > 0 ? 1 : -1);
      else if (dt < 1500 && abs(dx) < 40 && abs(dy) < 40) onTap(tX0, tY0);
    }
  }
  wasPressed = pressed;
}

// Forward declarations for shared time and animation helpers.
void openClock(Screen *returnTo);  // Forward declaration.
int sceneHour();
uint8_t currentDayPhase();
StrId dayPhaseTextId(uint8_t phase);
uint32_t pmdActTotalMs(const PmdAct &a);

/**
 * Routes vertical swipes to the active screen or opens the clock/card from home.
 *
 * @param dir Positive for a downward swipe, negative for an upward swipe.
 */
void onSwipeV(int dir) {
  if (pet.awaitingStarter()) return;  // Ignore input while choosing a starter.
  if (wildPromptUntil && deadlineActive(millis(), wildPromptUntil)) return;
  if (wildPromptUntil) wildPromptUntil = 0;
  if (gameMenuOpen) return;
  if (pet.ceremony) return;
  if (activeScreen) {
    activeScreen->handleSwipeV(dir);
    return;
  }

  mainScreen.handleSwipeV(dir);
}

/**
 * Routes horizontal swipes to the active screen or opens the Dex/party from home.
 *
 * @param dir Negative for left; positive for right.
 */
void onSwipe(int dir) {
  if (pet.awaitingStarter()) return;  // Ignore input while choosing a starter.
  if (wildPromptUntil && deadlineActive(millis(), wildPromptUntil)) return;
  if (wildPromptUntil) wildPromptUntil = 0;
  if (gameMenuOpen) return;
  if (activeScreen) {
    activeScreen->handleSwipe(dir);
    return;
  }
  mainScreen.handleSwipe(dir);
}

/**
 * Sends taps to the active screen, falling back to the main screen when none is active.
 *
 * @param x Horizontal display coordinate.
 * @param y Vertical display coordinate.
 */
void onTap(int16_t x, int16_t y) {
  // Serial.printf("TOUCH %d %d\n", x, y);  // Disabled because it floods the serial log.
  if (activeScreen) {
    Screen *tappedScreen = activeScreen;
    activeScreen->handleTap(x, y);
    if (activeScreen == tappedScreen && tappedScreen->shouldClose())
      setScreen(nullptr);
    return;
  }
  mainScreen.handleTap(x, y);
}

// Shared rendering utilities and screen dispatch.

bool gNight = false;  // Set by render() from local time or pet sleep state.
/**
 * Returns the foreground ink color for the current day/night scene.
 *
 * @return The active UI ink color.
 */
uint16_t inkColor() { return gNight ? UI_INK_NIGHT : UI_INK; }

// Background-scene rendering based on biome and real-time clock.

#define C565(r, g, b) ((uint16_t)((((r) >> 3) << 11) | (((g) >> 2) << 5) | ((b) >> 3)))
#define HORIZON 232  // Boundary between the sky and ground.

/**
 * Interpolates between two RGB565 colors.
 *
 * @param a Starting color.
 * @param b Ending color.
 * @param i Current interpolation step.
 * @param n Total interpolation steps.
 * @return The interpolated RGB565 color.
 */
uint16_t lerp565(uint16_t a, uint16_t b, int i, int n) {
  if (n <= 0) return a;
  int ar = (a >> 11) & 31, ag = (a >> 5) & 63, ab = a & 31;
  int br = (b >> 11) & 31, bg = (b >> 5) & 63, bb = b & 31;
  return (uint16_t)((((ar + (br - ar) * i / n) << 11)) |
                    (((ag + (bg - ag) * i / n) << 5)) | (ab + (bb - ab) * i / n));
}

/**
 * Selects the watermark corner, rotating every 20 seconds.
 *
 * @return The current corner index.
 */
static uint8_t watermarkSlot() {
  return (uint8_t)((millis() / 20000UL) & 3U);
}

/**
 * Indicates whether the watermark has moved to a new corner and needs redrawing.
 *
 * @return True when the current frame should be refreshed.
 */
bool watermarkNeedsRedraw() {
  return !screenOff && watermarkDrawnSlot != (int8_t)watermarkSlot();
}

/**
 * Blends a watermark tint into a pixel while preserving contrast.
 *
 * @param base Original RGB565 pixel color.
 * @return The tinted RGB565 color.
 */
static uint16_t watermarkPixel(uint16_t base) {
  int r = ((base >> 11) & 31) * 255 / 31;
  int g = ((base >> 5) & 63) * 255 / 63;
  int b = (base & 31) * 255 / 31;
  int luminance = (r * 30 + g * 59 + b * 11) / 100;
  return lerp565(base, luminance > 145 ? 0x0000 : 0xFFFF, 1, 4);
}

/**
 * Draws the small watermark glyphs into the current framebuffer slot.
 *
 * @param slot Watermark corner index.
 */
static void drawWatermark(uint8_t slot) {
  static const uint8_t GLYPHS[3][7] = {
    { 0x0E, 0x11, 0x17, 0x15, 0x17, 0x10, 0x0E },  // @
    { 0x1F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E },  // S
    { 0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F },  // E
  };
  static const int16_t POS[4][2] = {
    { 74, 74 }, { 374, 74 }, { 74, 384 }, { 374, 384 },
  };
  uint16_t *fb = gfx->getFramebuffer();
  if (!fb) return;
  int16_t ox = POS[slot][0];
  int16_t oy = POS[slot][1];
  for (uint8_t glyph = 0; glyph < 3; glyph++) {
    for (uint8_t row = 0; row < 7; row++) {
      uint8_t bits = GLYPHS[glyph][row];
      for (uint8_t col = 0; col < 5; col++) {
        if (!(bits & (1U << (4 - col)))) continue;
        int16_t x = ox + glyph * 6 + col;
        int16_t y = oy + row;
        if (x < 0 || x >= LCD_WIDTH || y < 0 || y >= LCD_HEIGHT) continue;
        uint32_t idx = (uint32_t)y * LCD_WIDTH + x;
        fb[idx] = watermarkPixel(fb[idx]);
      }
    }
  }
}

/**
 * Stamps the current frame with a watermark and submits it to the display.
 */
void flushStampedFrame() {
  uint8_t slot = watermarkSlot();
  drawWatermark(slot);
  watermarkDrawnSlot = (int8_t)slot;
  gfx->flush();
}

/**
 * Returns the pet's current local-scene hour derived from its synchronized clock.
 *
 * @return Hour of day in the range 0-23.
 */
int sceneHour() {
  return sceneHourFromEpoch(pet.lastSeenEpoch);
}

/**
 * Maps the current scene hour to a day-phase category.
 *
 * @return The phase identifier consumed by encounter and UI logic.
 */
uint8_t currentDayPhase() {
  return dayPhaseFromHour(sceneHour());
}

/**
 * Maps a day-phase identifier to its localized text resource.
 *
 * @param phase Day-phase identifier.
 * @return The matching localization string identifier.
 */
StrId dayPhaseTextId(uint8_t phase) {
  switch (phase) {
    case 0: return S_MORNING;
    case 2: return S_EVENING;
    case 3: return S_NIGHT;
    default: return S_DAY;
  }
}

// Daytime ground colors for each biome; night scenes blend them toward blue.
const uint16_t BIOME_SOIL[6] = {
  C565(0x7e, 0xc0, 0x7f),  // 0 meadow
  C565(0xdc, 0xca, 0x94),  // 1 beach
  C565(0x4f, 0x8a, 0x55),  // 2 forest
  C565(0x8a, 0x55, 0x44),  // 3 volcano
  C565(0xa8, 0x90, 0x6a),  // 4 mountain
  C565(0xe6, 0xee, 0xf5),  // 5 snow
};
/**
 * Renders the active screen, or the main screen when no modular screen is active.
 */
void render() {
  if (watermarkNeedsRedraw()) {
    cardDirty = true;
    clockDirty = true;
    helpDirty = true;
    keyboardDirty = true;
    gameMenuDirty = true;
    battleScreen.markDirty();
    if (activeScreen) activeScreen->markDirty();
  }
  if (staticScreenClean()) { perfRenderSkipCount++; return; }
  if (activeScreen) {
    Screen *renderingScreen = activeScreen;
    renderingScreen->render();
    if (activeScreen == renderingScreen && renderingScreen->shouldClose())
      setScreen(nullptr);
    return;
  }
  mainScreen.render();
}

// Shared minigame background renderer.
void drawGameScene();  // Forward declaration; implementation follows.

/**
 * Draws the shared minigame background using the current hour and pet biome.
 */
void drawGameScene() {
  int hh = sceneHour();
  bool night = hh < 6 || hh >= 20;
  uint16_t top, bot;
  if (night)       { top = C565(0x0c, 0x12, 0x24); bot = C565(0x1e, 0x26, 0x46); }
  else if (hh < 8) { top = C565(0xd1, 0x6a, 0x86); bot = C565(0xf3, 0xb8, 0x7c); }
  else if (hh < 18){ top = C565(0x8f, 0xc8, 0xea); bot = C565(0xdc, 0xee, 0xe6); }
  else             { top = C565(0xc7, 0x5a, 0x4a); bot = C565(0xf0, 0xae, 0x64); }
  int hor = 376;
  for (int y = 0; y < hor; y += 8)
    gfx->fillRect(0, y, 466, 8, lerp565(top, bot, y, hor));
  if (night)
    for (auto &st : STARS) gfx->fillRect(st[0], st[1], 4, 4, UI_WHITE);
  uint8_t bio = pet.isEgg() ? 0 : DEX_TBL[pet.speciesId].biome;
  uint16_t soil = BIOME_SOIL[bio < 6 ? bio : 0];
  if (night) soil = lerp565(soil, C565(0x16, 0x1c, 0x30), 9, 16);
  gfx->fillRect(0, hor, 466, 466 - hor, soil);
}

/**
 * Opens time settings initialized from the pet's current clock.
 *
 * The entered time is treated as local wall-clock time; no timezone conversion
 * is applied, and the settings screen preserves the current calendar day.
 */
void openClock(Screen *returnTo) {
  uint32_t e = pet.lastSeenEpoch ? pet.lastSeenEpoch : rtcEpoch();
  clockH = (e / 3600) % 24;
  clockM = (e / 60) % 60;
  clockDirty = true;
  clockSettingsScreen.setReturnScreen(returnTo);
  setScreen(&clockSettingsScreen);
  sfxPlay(SFX_MENU);
}

/**
 * Opens the help screen at its first page.
 */
void openHelp() {
  helpPage = 0;
  helpDirty = true;
  setScreen(&helpScreen);
  sfxPlay(SFX_MENU);
}

/**
 * Opens the rename keyboard and copies the current pet name into its edit buffer.
 */
void openKeyboard(Screen *returnTo) {
  keyboardDirty = true;
  keyboardScreen.setReturnScreen(returnTo);
  setScreen(&keyboardScreen);
  strncpy(nameBuf, pet.nick, sizeof(nameBuf) - 1);
  nameBuf[sizeof(nameBuf) - 1] = 0;
  nameLen = strlen(nameBuf);
  sfxPlay(SFX_MENU);
}

#define GAL_X 73
#define GAL_Y 116
#define GAL_CELL 74

/**
 * Draws a sprite thumbnail centered in a gallery cell.
 *
 * @param b Encoded sprite data containing dimensions, palette, and pixels.
 * @param x Left edge of the gallery cell.
 * @param y Top edge of the gallery cell.
 * @param s Integer pixel scale.
 * @param sil Whether to render the sprite as a solid silhouette.
 */
void drawThumb(const uint8_t *b, int x, int y, int s, bool sil) {
  uint8_t w = b[0], h = b[1], n = b[2];
  const uint8_t *pal = b + 3;
  const uint8_t *d = pal + n * 2;
  int ox = x + (GAL_CELL - w * s) / 2;
  int oy = y + (GAL_CELL - h * s) / 2;
  for (int r = 0; r < h; r++) {
    for (int c = 0; c < w; c++) {
      uint8_t idx = d[r * w + c];
      if (idx == 0xFF) continue;
      uint16_t col = sil ? INK_K : (uint16_t)(pal[idx * 2] | (pal[idx * 2 + 1] << 8));
      gfx->fillRect(ox + c * s, oy + r * s, s, s, col);
    }
  }
}





// PMD animation timing and drawing helpers.

/**
 * Sums the frame durations for one PMD action.
 *
 * @param a PMD action whose frame durations should be summed.
 * @return Total duration in milliseconds, or 100 ms when no duration is defined.
 */
uint32_t pmdActTotalMs(const PmdAct &a) {
  uint32_t t = 0;
  for (uint8_t i = 0; i < a.frames; i++) t += a.ms[i];
  return t ? t : 100;
}

/**
 * Selects the animation frame for an elapsed time, either looping or clamping at the end.
 *
 * @param a PMD action to sample.
 * @param t Elapsed animation time in milliseconds.
 * @param loop Whether the action should repeat after its final frame.
 * @return Frame index for the requested time.
 */
uint8_t pmdFrameAt(const PmdAct &a, uint32_t t, bool loop) {
  uint32_t total = pmdActTotalMs(a);
  if (!loop && t >= total) return a.frames - 1;
  t %= total;
  uint8_t i = 0;
  while (t >= a.ms[i]) {
    t -= a.ms[i];
    i = (i + 1) % a.frames;
  }
  return i;
}

/**
 * Draws a frame from a specific PMD animation, anchored to its ground baseline.
 *
 * @param m PMD sprite and animation data to render.
 * @param actId Action identifier in the PMD animation table.
 * @param cx Horizontal center of the sprite.
 * @param groundY Vertical ground baseline.
 * @param t Elapsed animation time in milliseconds.
 * @param loop Whether the action should loop.
 * @param sil Whether to render the sprite as a silhouette.
 * @param maxS Maximum integer scale allowed for the sprite.
 */
void drawPmdActM(PmdMon &m, uint8_t actId, int cx, int groundY, uint32_t t, bool loop, bool sil, uint8_t maxS) {
  const PmdAct &a = m.acts[actId];
  if (!a.frames) return;
  uint8_t sBase = m.acts[PMD_IDLE].h ? 170 / m.acts[PMD_IDLE].h : 5;
  if (sBase < 2) sBase = 2;
  if (sBase > maxS) sBase = maxS;
  uint8_t s = sBase;
  while (s > 2 && a.h * s > 250) s--;  // Reduce oversized frames, such as attacks.
  uint8_t fi = pmdFrameAt(a, t, loop);
  const uint8_t *fr = a.data + (uint32_t)fi * a.w * a.h;
  // Anchor by the feet (a.base), not the full canvas height, so actions with
  // different padding (such as Hurt or Eat) share the same ground baseline.
  int x0 = cx - a.w * s / 2, y0 = groundY - (a.base ? a.base : a.h) * s;
  for (int r = 0; r < a.h; r++) {
    const uint8_t *row = fr + r * a.w;
    for (int c = 0; c < a.w; c++) {
      uint8_t idx = row[c];
      if (idx == 0xFF) continue;
      gfx->fillRect(x0 + c * s, y0 + r * s, s, s, sil ? INK_K : m.pal[idx]);
    }
  }
}
/**
 * Draws an action from the current pet's global PMD sprite.
 *
 * @param actId Action identifier in the PMD animation table.
 * @param cx Horizontal center of the sprite.
 * @param groundY Vertical ground baseline.
 * @param t Elapsed animation time in milliseconds.
 * @param loop Whether the action should loop.
 * @param sil Whether to render the sprite as a silhouette.
 * @param maxS Maximum integer scale allowed for the sprite.
 */
void drawPmdAct(uint8_t actId, int cx, int groundY, uint32_t t, bool loop, bool sil, uint8_t maxS) {
  drawPmdActM(pmd, actId, cx, groundY, t, loop, sil, maxS);
}

/**
 * Draws an n-by-n character map at an integer scale.
 *
 * @param map Character map whose non-period characters select sprite colors.
 * @param n Width and height of the square map.
 * @param x Left edge of the rendered map.
 * @param y Top edge of the rendered map.
 * @param s Integer pixel scale.
 * @param silhouette Whether to render every visible pixel in the ink color.
 */
void drawMap(const char *const *map, int n, int x, int y, int s, bool silhouette) {
  for (int r = 0; r < n; r++) {
    for (int c = 0; c < n; c++) {
      char ch = map[r][c];
      if (ch == '.') continue;
      gfx->fillRect(x + c * s, y + r * s, s, s, silhouette ? INK_K : spriteColor(ch));
    }
  }
}
